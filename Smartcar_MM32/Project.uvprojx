# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MM32SPIN27PS MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.6
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Hardware;.\MN32_HAL;.\Startup;.\User;.\Include;.\Control
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Hardware
    ./Hardware/: board.c board.h common.c common.h headfile.h SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_ABSOLUTE_ENCODER.c SEEKFREE_ABSOLUTE_ENCODER.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V03X.c SEEKFREE_MT9V03X.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h SEEKFREE_UART_7725.c SEEKFREE_UART_7725.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h zf_adc.c zf_adc.h zf_camera.c zf_camera.h zf_exti.c zf_exti.h zf_flash.c zf_flash.h zf_gpio.c zf_gpio.h zf_pit.c zf_pit.h zf_pwm.c zf_pwm.h zf_spi.c zf_spi.h zf_systick.c zf_systick.h zf_tim.c zf_tim.h zf_uart.c zf_uart.h
  group MN32_HAL
    ./MN32_HAL/: dtype.h hal_adc.c hal_adc.h hal_bkp.c hal_bkp.h hal_comp.c hal_comp.h hal_conf.h hal_crc.c hal_crc.h hal_dbg.c hal_dbg.h hal_device.h hal_div.c hal_div.h hal_dma.c hal_dma.h hal_exti.c hal_exti.h hal_flash.c hal_flash.h hal_gpio.c hal_gpio.h hal_i2c.c hal_i2c.h hal_iwdg.c hal_iwdg.h hal_misc.c hal_misc.h hal_opamp.c hal_opamp.h hal_pwr.c hal_pwr.h hal_rcc.c hal_rcc.h hal_redefine.h hal_spi.c hal_spi.h hal_sqrt.c hal_sqrt.h hal_syscfg.h hal_tim.c hal_tim.h hal_uart.c hal_uart.h hal_uid.c hal_uid.h hal_ver.c hal_ver.h hal_wwdg.c hal_wwdg.h
  group Startup
    ./Startup/: startup_mm32spin2xx_p_keil.s system_mm32spin2xx_p.c
  group User
    ./User/: isr.c isr.h main.c
  group Include
    ./Include/: mm32_device.h mm32_reg.h mm32_reg_redefine_v1.h reg_adc.h reg_bkp.h reg_common.h reg_comp.h reg_crc.h reg_dbg.h reg_div.h reg_dma.h reg_exti.h reg_flash.h reg_gpio.h reg_i2c.h reg_iwdg.h reg_opamp.h reg_pwm.h reg_pwr.h reg_rcc.h reg_root.h reg_spi.h reg_syscfg.h reg_tim.h reg_uart.h reg_wwdg.h types.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cm23.h core_sc000.h core_sc300.h
  group Control
    ./Control/: ADC.c ADC.h Init.c Init.h PD.c PD.h Path.c Path.h OLED.c OLED.h UART.c UART.h
