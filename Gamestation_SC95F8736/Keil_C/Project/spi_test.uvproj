# Keil uVision project spi_test.uvproj, settings and files
target <spi_test> (MCS-51)
  device: SC95F8736 SC95Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0xFFF) CLOCK(32000000)
  output: spi_test +hex
  c flags: Optimize=8
  c define: SC95F8x3x
  c include: ..\FWLib\SC95F_Lib\inc;..\User;..\Bank1;..\Bank2;..\Bank3
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c SC_Init.c SC_it.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c
  group Drivers
    ../Drivers/SCDriver_Joystick/C/: SCDriver_Joystick.c
  group FWLib
    ../FWLib/SC95F_Lib/src/: sc95f_adc.c sc95f_timer4.c sc95f_pwm.c sc95f_timer3.c sc95f_usci3.c sc95f_uart0.c sc95f_usci2.c sc95f_timer2.c sc95f_usci0.c sc95f_timer0.c sc95f_gpio.c sc95f_option.c
  group Startup
    ./: STARTUP.A51 L51_BANK.A51
  group Bank1
    ../Bank1/: Delay.c bank1_work.c bank1_work.h Font.h GUI.c GUI.h LCD_Config.h Lcd_Driver.c Lcd_Driver.h
  group Bank2
    ../Bank2/: bank2_work.c basic_draw.c basic_draw.h data.h draw.c draw.h run.c run.h Key.c Key.h run2.c run2.h
  group Bank3
    ../Bank3/: bank3_work.c esp8266.c esp8266.h bank3_work.h beep.c beep.h data2.h music.c music.h SHT30.c SHT30.h
